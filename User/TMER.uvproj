# Keil uVision project TMER.uvproj, settings and files
target TMER (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: TMER +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hardware
  group User
    ./: main.c
  group Hardware
    ../Hardware/: UART1.C UART2.C EEPROM.C Timer0.c PCA.c KEY.C Menu.c DS1302.C IIC.c OLED.C
